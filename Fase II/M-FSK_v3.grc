options:
  parameters:
    author: homero
    generate_options: qt_gui
    id: sistemabase
    output_language: python
    title: sistemabase
  states: {}

blocks:
- name: Dtiming
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Dtiming
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps-1
    value: '0'
  states: {}
- name: Fc
  id: variable
  parameters:
    value: fd*8
  states: {}
- name: Kf
  id: variable
  parameters:
    value: fd/Rs
  states: {}
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '4'
    value: '0.2'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Retardo_sym
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Delay transmited signal to match with the received signal
    rangeType: int
    start: '0'
    step: '1'
    stop: Sps*10
    value: '0'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/bps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: int(8*Kf*M)
  states: {}
- name: Tp
  id: variable
  parameters:
    value: int(Sps/(Kf*4))
  states: {state: disabled}
- name: bps
  id: variable
  parameters:
    value: math.log(M,2)
  states: {}
- name: fd
  id: variable
  parameters:
    value: 2*Rs
  states: {}
- name: h0
  id: variable
  parameters:
    value: ([1]*Sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: E3TRadio_acumulador_truncado_ff_0
  id: E3TRadio_acumulador_truncado_ff
  parameters:
    M: '0'
    N: Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,1
    label0: T1 R1
    label1: T2 R2
    label2: T3 R3
    label3: Eye Diagramm
    label4: Timing
    label5: RF
    label6: constelaciones
    num_tabs: '7'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '-(M-1)/2'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_u_M_PAM_bb_0
  id: b_u_M_PAM_bb
  parameters:
    M: M
  states: {}
- name: b_upconverter_cf_0
  id: b_upconverter_cf
  parameters:
    Fc: Fc
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi/samp_rate
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*fd
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,1,0,1,0,0,0,1,0,1,0,1,1,1,0,0,0)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Complex envelope"""

          def __init__(self,):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_EC_fc',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )

          def work(self, input_items, output_items):
              Q=input_items[0]
              A=input_items[1]
              Sec=output_items[0]
              Sec[:]=A*np.exp(1j*Q)
              return len(Sec)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h0
    type: fff
  states: {}
- name: mis_funciones
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport numpy as np\nimport math\n\ndef nyq(Sps,ntaps):\n    k=np.linspace(-ntaps/2, ntaps/2-1, ntaps)\n    h=np.sinc(k/Sps)\n    return h\n    \n#######################################################\n##                  Delta                            ##\n#######################################################                       \ndef delta(ntaps):\n    cerosd=(   [0]*(int(ntaps/2)-1)    )\n    cerosdi=(   [0]*(int(ntaps/2))     )\n    delta_i= np.concatenate(( cerosdi, ([1]) ))\n    delta=np.concatenate(( delta_i, cerosd ))\n    return delta\n   \n#######################################################\n##               Forma Coseno Alzado                 ##\n#######################################################                       \ndef rcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if abs(k)==Sps/(2.*beta):\n                h[n]=np.sinc(1./(2.*beta))*math.pi/4.\n            else:\n                h[n]=np.sinc(k/Sps)*math.cos(beta*k*math.pi/Sps)/(1.-(2.*beta*k/Sps)**2)                \n    Amp=np.amax(h)\n    return h/Amp\n    \n#######################################################\n##            Forma Raiz de Coseno Alzado            ##\n#######################################################                       \n\ndef rrcos(Sps,ntaps,beta):\n    if beta==0:\n        h=nyq(Sps,ntaps)\n    else:\n        h=ntaps*[0,]\n        beta4=4.*beta\n        for n in range(ntaps):\n            k=n-ntaps/2. # esto es para que h[n] quede centrada en la mitad del vector\n            if k==0:\n                h[n]=1+beta*(4./math.pi-1.)\n            elif abs(k)==Sps/beta4:\n                ha=(1.+2./math.pi)*math.sin(math.pi/beta4)\n                hb=(1.-2./math.pi)*math.cos(math.pi/beta4)\n                h[n]=(ha+hb)*beta/math.sqrt(2.)\n            else:\n                ks=k/Sps\n                kspi=math.pi*ks\n                Num=math.sin(kspi*(1-beta))+beta4*ks*math.cos(kspi*(1+beta))\n                Den=kspi*(1.-(beta4*ks)**2)\n                h[n]=Num/Den                \n    Amp=np.amax(h)\n    return h/Amp\n\n"
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@6:0,1,1,1
    label1: T2
    label2: R2
    marker1: '-1'
    nconnections: '2'
    size: '1024'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: Menu@3:0,0,1,1
    label1: R2
    label2: R2.0
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    width1: '4'
    width2: '4'
    ymax: '6'
    ymin: '-6'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8+8
    gui_hint: Menu@1:1,0,1,1
    label1: T2
    label2: R2
    name: '"Espectro en dB"'
    nconnections: '2'
    type: complex
    width1: '3'
    width2: '3'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:0,0,1,1
    label1: I signal Tx
    label2: Q Signal Tx
    label3: I signal Rx
    label4: Q signal Rx
    nconnections: '2'
    size: 6*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@5:0,0,1,1
    name: '"Senal RF"'
    size: int(Sps*18)
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Ruido
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: T-1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: T2
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}

connections:
- [E3TRadio_acumulador_truncado_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_const_source_x_0, '0', blocks_add_xx_1, '1']
- [analog_const_source_x_1, '0', epy_block_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', virtual_sink_0_0_0, '0']
- [analog_random_source_x_0, '0', b_u_M_PAM_bb_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_0_2_0, '0']
- [b_u_M_PAM_bb_0, '0', blocks_char_to_float_1, '0']
- [b_upconverter_cf_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0_1, '0']
- [blocks_add_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_char_to_float_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_1, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_0_2_0, '0']
- [epy_block_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '0', virtual_sink_0_0, '0']
- [interp_fir_filter_xxx_0, '0', E3TRadio_acumulador_truncado_ff_0, '0']
- [virtual_source_0_0, '0', b_upconverter_cf_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_0_1, '0', qtgui_const_sink_x_0_0, '1']
- [virtual_source_0_0_1, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0_0_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_0_1, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
