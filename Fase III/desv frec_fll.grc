options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: EsN0max
  id: variable
  parameters:
    value: '25'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '-5'
  states: {}
- name: M0
  id: variable
  parameters:
    value: len(const0)
  states: {}
- name: MaxCount
  id: variable
  parameters:
    value: int(1e7)
  states: {}
- name: MaxErrors
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: MiconstellationObject0
  id: variable_constellation
  parameters:
    const_points: const0
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: mapa
    type: calcdist
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '32'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const0
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {}
- name: fd
  id: variable
  parameters:
    value: '4.8'
  states: {}
- name: mapa
  id: variable
  parameters:
    value: np.arange(M0)
  states: {}
- name: my_const_obj
  id: variable_constellation
  parameters:
    const_points: const0
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0,1]'
    type: calcdist
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: M0
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fd
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: b_FLL_tunner_0
  id: b_FLL_tunner
  parameters:
    ConstellationObject: my_const_obj
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const0
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject0
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: R2.0
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: TX0
  states: {}
- name: vs0_1_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: vs0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R2.0
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: RX0
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_1, '0', vs0_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [b_FLL_tunner_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [b_FLL_tunner_0, '0', vs0_1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', b_FLL_tunner_0, '0']
- [blocks_multiply_xx_0, '0', vs0_1_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_add_xx_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', vs1_0_0, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0, '1']

metadata:
  file_format: 1
