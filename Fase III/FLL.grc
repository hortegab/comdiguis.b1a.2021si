options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: M0
  id: variable
  parameters:
    value: len(const0)
  states: {}
- name: Noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Noise
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const0
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {}
- name: f_d
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Desviacion de Frecuencia
    start: '0'
    step: 1400/100
    stop: '1400'
    value: '0'
  states: {}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: np.exp(math.pi/8*1j)
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: Noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: M0
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_d
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: b_FLL_tunner2_0
  id: b_FLL_tunner2
  parameters:
    Constellation: const0
  states: {}
- name: b_demod_constelacion_cb_0
  id: b_demod_constelacion_cb
  parameters:
    Constelacion: const0
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const0
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'CAPA: CANAL'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'CAPA: PRE-CANAL'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 'CAPA: MODULACION'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 7,0,1,1
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 7,1,1,2
    label1: T-1
    label2: R-1
    marker1: '0'
    marker2: '0'
    nconnections: '2'
    size: '1024'
    srate: Rs
    stemplot: 'True'
    type: float
    ymax: '9'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: R2
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: R2.0
  states: {}
- name: virtual_source_0_1_1_0_0
  id: virtual_source
  parameters:
    stream_id: R-1
  states: {}
- name: virtual_source_0_1_1_1
  id: virtual_source
  parameters:
    stream_id: T-1
  states: {}
- name: vs0_1
  id: virtual_sink
  parameters:
    stream_id: T-1
  states: {}
- name: vs0_1_0
  id: virtual_sink
  parameters:
    stream_id: R2
  states: {}
- name: vs0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: R2.0
  states: {}
- name: vs0_1_0_1
  id: virtual_sink
  parameters:
    stream_id: T2
  states: {}
- name: vs1_0_0
  id: virtual_sink
  parameters:
    stream_id: R-1
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_1, '0', digital_chunks_to_symbols_xx_1, '0']
- [analog_random_source_x_1, '0', vs0_1, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [b_FLL_tunner2_0, '0', b_demod_constelacion_cb_0, '0']
- [b_FLL_tunner2_0, '0', vs0_1_0_0, '0']
- [b_demod_constelacion_cb_0, '0', blocks_null_sink_0, '0']
- [b_demod_constelacion_cb_0, '0', vs1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '2']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_multiply_xx_0, '0', b_FLL_tunner2_0, '0']
- [blocks_multiply_xx_0, '0', vs0_1_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', vs0_1_0_1, '0']
- [virtual_source_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0, '0', qtgui_const_sink_x_0, '1']
- [virtual_source_0_1_1_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [virtual_source_0_1_1_1, '0', blocks_char_to_float_0_1, '0']

metadata:
  file_format: 1
